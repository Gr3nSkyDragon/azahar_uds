/* Copyright 2026 Azahar Emulator Project. Licensed under GPLv2 or any later version. */
#include "screen.h"

#include <string.h>

/* The common 5x7 terminal font, ' ' to '~': five columns per glyph, bit 0 the top row. */
static const uint8_t kFont[95][GLYPH_W] = {
    {0x00, 0x00, 0x00, 0x00, 0x00}, {0x00, 0x00, 0x5f, 0x00, 0x00}, {0x00, 0x07, 0x00, 0x07, 0x00}, /*   ! " */
    {0x14, 0x7f, 0x14, 0x7f, 0x14}, {0x24, 0x2a, 0x7f, 0x2a, 0x12}, {0x23, 0x13, 0x08, 0x64, 0x62}, /* # $ % */
    {0x36, 0x49, 0x55, 0x22, 0x50}, {0x00, 0x05, 0x03, 0x00, 0x00}, {0x00, 0x1c, 0x22, 0x41, 0x00}, /* & ' ( */
    {0x00, 0x41, 0x22, 0x1c, 0x00}, {0x14, 0x08, 0x3e, 0x08, 0x14}, {0x08, 0x08, 0x3e, 0x08, 0x08}, /* ) * + */
    {0x00, 0x50, 0x30, 0x00, 0x00}, {0x08, 0x08, 0x08, 0x08, 0x08}, {0x00, 0x60, 0x60, 0x00, 0x00}, /* , - . */
    {0x20, 0x10, 0x08, 0x04, 0x02}, {0x3e, 0x51, 0x49, 0x45, 0x3e}, {0x00, 0x42, 0x7f, 0x40, 0x00}, /* / 0 1 */
    {0x42, 0x61, 0x51, 0x49, 0x46}, {0x21, 0x41, 0x45, 0x4b, 0x31}, {0x18, 0x14, 0x12, 0x7f, 0x10}, /* 2 3 4 */
    {0x27, 0x45, 0x45, 0x45, 0x39}, {0x3c, 0x4a, 0x49, 0x49, 0x30}, {0x01, 0x71, 0x09, 0x05, 0x03}, /* 5 6 7 */
    {0x36, 0x49, 0x49, 0x49, 0x36}, {0x06, 0x49, 0x49, 0x29, 0x1e}, {0x00, 0x36, 0x36, 0x00, 0x00}, /* 8 9 : */
    {0x00, 0x56, 0x36, 0x00, 0x00}, {0x08, 0x14, 0x22, 0x41, 0x00}, {0x14, 0x14, 0x14, 0x14, 0x14}, /* ; < = */
    {0x00, 0x41, 0x22, 0x14, 0x08}, {0x02, 0x01, 0x51, 0x09, 0x06}, {0x32, 0x49, 0x79, 0x41, 0x3e}, /* > ? @ */
    {0x7e, 0x11, 0x11, 0x11, 0x7e}, {0x7f, 0x49, 0x49, 0x49, 0x36}, {0x3e, 0x41, 0x41, 0x41, 0x22}, /* A B C */
    {0x7f, 0x41, 0x41, 0x22, 0x1c}, {0x7f, 0x49, 0x49, 0x49, 0x41}, {0x7f, 0x09, 0x09, 0x09, 0x01}, /* D E F */
    {0x3e, 0x41, 0x49, 0x49, 0x7a}, {0x7f, 0x08, 0x08, 0x08, 0x7f}, {0x00, 0x41, 0x7f, 0x41, 0x00}, /* G H I */
    {0x20, 0x40, 0x41, 0x3f, 0x01}, {0x7f, 0x08, 0x14, 0x22, 0x41}, {0x7f, 0x40, 0x40, 0x40, 0x40}, /* J K L */
    {0x7f, 0x02, 0x0c, 0x02, 0x7f}, {0x7f, 0x04, 0x08, 0x10, 0x7f}, {0x3e, 0x41, 0x41, 0x41, 0x3e}, /* M N O */
    {0x7f, 0x09, 0x09, 0x09, 0x06}, {0x3e, 0x41, 0x51, 0x21, 0x5e}, {0x7f, 0x09, 0x19, 0x29, 0x46}, /* P Q R */
    {0x46, 0x49, 0x49, 0x49, 0x31}, {0x01, 0x01, 0x7f, 0x01, 0x01}, {0x3f, 0x40, 0x40, 0x40, 0x3f}, /* S T U */
    {0x1f, 0x20, 0x40, 0x20, 0x1f}, {0x3f, 0x40, 0x38, 0x40, 0x3f}, {0x63, 0x14, 0x08, 0x14, 0x63}, /* V W X */
    {0x07, 0x08, 0x70, 0x08, 0x07}, {0x61, 0x51, 0x49, 0x45, 0x43}, {0x00, 0x7f, 0x41, 0x41, 0x00}, /* Y Z [ */
    {0x02, 0x04, 0x08, 0x10, 0x20}, {0x00, 0x41, 0x41, 0x7f, 0x00}, {0x04, 0x02, 0x01, 0x02, 0x04}, /* \ ] ^ */
    {0x40, 0x40, 0x40, 0x40, 0x40}, {0x00, 0x01, 0x02, 0x04, 0x00}, {0x20, 0x54, 0x54, 0x54, 0x78}, /* _ ` a */
    {0x7f, 0x48, 0x44, 0x44, 0x38}, {0x38, 0x44, 0x44, 0x44, 0x20}, {0x38, 0x44, 0x44, 0x48, 0x7f}, /* b c d */
    {0x38, 0x54, 0x54, 0x54, 0x18}, {0x08, 0x7e, 0x09, 0x01, 0x02}, {0x0c, 0x52, 0x52, 0x52, 0x3e}, /* e f g */
    {0x7f, 0x08, 0x04, 0x04, 0x78}, {0x00, 0x44, 0x7d, 0x40, 0x00}, {0x20, 0x40, 0x44, 0x3d, 0x00}, /* h i j */
    {0x7f, 0x10, 0x28, 0x44, 0x00}, {0x00, 0x41, 0x7f, 0x40, 0x00}, {0x7c, 0x04, 0x18, 0x04, 0x78}, /* k l m */
    {0x7c, 0x08, 0x04, 0x04, 0x78}, {0x38, 0x44, 0x44, 0x44, 0x38}, {0x7c, 0x14, 0x14, 0x14, 0x08}, /* n o p */
    {0x08, 0x14, 0x14, 0x18, 0x7c}, {0x7c, 0x08, 0x04, 0x04, 0x08}, {0x48, 0x54, 0x54, 0x54, 0x20}, /* q r s */
    {0x04, 0x3f, 0x44, 0x40, 0x20}, {0x3c, 0x40, 0x40, 0x20, 0x7c}, {0x1c, 0x20, 0x40, 0x20, 0x1c}, /* t u v */
    {0x3c, 0x40, 0x30, 0x40, 0x3c}, {0x44, 0x28, 0x10, 0x28, 0x44}, {0x0c, 0x50, 0x50, 0x50, 0x3c}, /* w x y */
    {0x44, 0x64, 0x54, 0x4c, 0x44}, {0x00, 0x08, 0x36, 0x41, 0x00}, {0x00, 0x00, 0x7f, 0x00, 0x00}, /* z { | */
    {0x00, 0x41, 0x36, 0x08, 0x00}, {0x10, 0x08, 0x08, 0x10, 0x08},                                 /* } ~ */
};

void fb_clear(uint8_t *fb)
{
    memset(fb, 0, SCREEN_BYTES);
}

void fb_set(uint8_t *fb, int x, int y, bool on)
{
    if ((unsigned)x >= SCREEN_W || (unsigned)y >= SCREEN_H) return;
    const uint8_t mask = (uint8_t)(1u << (y & 7));
    uint8_t *byte = fb + x + SCREEN_W * (y >> 3);
    *byte = on ? (uint8_t)(*byte | mask) : (uint8_t)(*byte & ~mask);
}

void fb_box(uint8_t *fb, int x, int y, int w, int h, bool on)
{
    for (int row = y; row < y + h; ++row)
        for (int col = x; col < x + w; ++col) fb_set(fb, col, row, on);
}

void fb_hline(uint8_t *fb, int x, int y, int w)
{
    fb_box(fb, x, y, w, 1, true);
}

void fb_vline(uint8_t *fb, int x, int y, int h)
{
    fb_box(fb, x, y, 1, h, true);
}

void fb_frame(uint8_t *fb, int x, int y, int w, int h)
{
    fb_hline(fb, x, y, w);
    fb_hline(fb, x, y + h - 1, w);
    fb_vline(fb, x, y, h);
    fb_vline(fb, x + w - 1, y, h);
}

/* The pixels whose centres lie within half a pixel of the circle (r^2 +- r). */
void fb_ring(uint8_t *fb, int cx, int cy, int r)
{
    for (int dy = -r; dy <= r; ++dy)
        for (int dx = -r; dx <= r; ++dx) {
            const int d = dx * dx + dy * dy;
            if (d >= r * r - r && d <= r * r + r) fb_set(fb, cx + dx, cy + dy, true);
        }
}

void fb_disc(uint8_t *fb, int cx, int cy, int r, bool on)
{
    for (int dy = -r; dy <= r; ++dy)
        for (int dx = -r; dx <= r; ++dx)
            if (dx * dx + dy * dy <= r * r + r) fb_set(fb, cx + dx, cy + dy, on);
}

void fb_image(uint8_t *fb, int x, int y, int w, int h, const uint8_t *bits, bool on)
{
    const int stride = (w + 7) / 8;
    for (int row = 0; row < h; ++row)
        for (int col = 0; col < w; ++col)
            if (bits[row * stride + col / 8] >> (7 - col % 8) & 1) fb_set(fb, x + col, y + row, on);
}

int fb_print(uint8_t *fb, int x, int y, const char *text, int scale)
{
    for (; *text; ++text) {
        const unsigned char c = (unsigned char)*text;
        const uint8_t *glyph = kFont[(c >= ' ' && c <= '~' ? c : '?') - ' '];
        for (int col = 0; col < GLYPH_W; ++col)
            for (int row = 0; row < GLYPH_H; ++row)
                if (glyph[col] >> row & 1) fb_box(fb, x + col * scale, y + row * scale, scale, scale, true);
        x += GLYPH_PITCH * scale;
    }
    return x;
}

int fb_print_width(const char *text, int scale)
{
    const int length = (int)strlen(text);
    return length ? (GLYPH_PITCH * length - 1) * scale : 0;
}

void fb_print_centered(uint8_t *fb, int x_offset, int y, const char *text, int scale)
{
    fb_print(fb, (SCREEN_W - fb_print_width(text, scale)) / 2 + x_offset, y, text, scale);
}

void fb_print_right(uint8_t *fb, int right, int y, const char *text, int scale)
{
    fb_print(fb, right - fb_print_width(text, scale), y, text, scale);
}
